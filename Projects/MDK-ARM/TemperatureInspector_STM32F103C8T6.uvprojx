# Keil uVision project TemperatureInspector_STM32F103C8T6.uvprojx, settings and files
target TemperatureInspector_STM32F103C8T6 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: TemperatureInspector_STM32F103C8T6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../../Inc;../../Middlewares/Third_Party/FatFs/src;../../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../../Drivers/STM32F1xx_HAL_Driver/Inc;../../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c app.c app_alarm.c app_ds18b20.c app_esp8266.c app_keys.c app_oled.c app_pt100.c app_settings.c app_storage.c
  group Drivers/STM32F1xx_HAL_Driver
    ../../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c
  group Middlewares/FatFs
    ../../Middlewares/Third_Party/FatFs/src/: ff.c diskio.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
